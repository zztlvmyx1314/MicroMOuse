# IAR project Maze.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103VB ST STM32F103VB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: $PROJ_DIR$; lib\inc; Scr; core; Scr\sys; C:\Users\zero\Desktop\实验室\电脑鼠\程序\电脑鼠需要封装\模拟吸盘鼠45度完善封装完成+冲刺\FZ; C:\Users\Administrator\Desktop\新建文件夹\模拟吸盘鼠45度完善完成+冲刺（给启诚）\模拟吸盘鼠45度完善封装完成+冲刺
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: C:\Users\Administrator\Desktop\新建文件夹\模拟吸盘鼠45度完善封装完成+冲刺\模拟吸盘鼠45度完善封装完成+冲刺
  OBJCOPY.OOCOutputFile: Maze.srec
  ILINK.IlinkOutputFile: Maze.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\ST\stm32f103xB.icf
  ILINK.IlinkAdditionalLibs: C:\Users\gxq19\Desktop\mn\Debug\Exe\Maze.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group lib
    lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group scr
    Scr/: main.c Mouse_Drive.c Mouse_Drive_Init.c stm32f10x_it.c stmflash.c Zlg7289.c
    core/: system_stm32f10x.c
  group startup
    core/: startup_stm32f10x_hd.s
